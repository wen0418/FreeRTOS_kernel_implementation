# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\freertos\Source\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\Fire_FreeRTOS.sct
  group user
    ../User/: main.c
  group FreeRTOS/Source
    ../freertos/Source/include/: list.h portmacro.h FreeRTOSConfig.h FreeRTOS.h task.h projdefs.h portable.h
    ../freertos/Source/: list.c task.c
    ../freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 6.1.1, Device:Startup 2.2.0
